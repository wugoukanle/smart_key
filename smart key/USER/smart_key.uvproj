# Keil uVision project smart_key.uvproj, settings and files
target smart_key (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: smart_key +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -output ..\Output\smart_key.bin  ..\Output\smart_key.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CM3;..\user;..\fwlib\inc;..\fwlib\src;..\Module\delay;..\Module\NVIC;..\Module\OLED;..\Module\usart;..\Module\RFID;..\Module\spi_flash;..\Module\bluetooth;..\Module\USB;..\Module\Timer;..\Module\Li_Power;..\Module\RTC;..\Module\IWDG;..\Module\sw_key;..\Module\wkup
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./: main.c stm32f10x_it.c Globle_Var.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group OLED
    ../Module/OLED/: oled.c
  group Delay
    ../Module/delay/: delay.c
  group NVIC
    ../Module/NVIC/: nvic.c
  group Bluetooth
    ../Module/bluetooth/: bluetooth.c
  group usart
    ../Module/usart/: usart.c
  group RFID
    ../Module/RFID/: rfid.c
  group flash
    ../Module/spi_flash/: spi_flash.c
  group USB
    ../Module/USB/: usb.c
  group Timer
    ../Module/Timer/: timer.c
  group RTC
    ../Module/RTC/: RTC_time.c
  group Li_Power
    ../Module/Li_Power/: Li_Power.c
  group IWDG
    ../Module/IWDG/: iwdg.c
  group sw_key
    ../Module/sw_key/: sw_key.c
  group wkup
    ../Module/wkup/: wkup.c
